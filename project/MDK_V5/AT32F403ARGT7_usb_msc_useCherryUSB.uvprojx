# Keil uVision project AT32F403ARGT7_usb_msc_useCherryUSB.uvprojx, settings and files
target AT32F403ARGT7_usb_msc_useCherryUSB (5060750::V5.06 update 6 (build 750)::.\ARMCC5)
  device: -AT32F403ARGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.9
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32F403ARGT7_usb_msc_useCherryUSB +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403ARGT7, USE_STDPERIPH_DRIVER, AT_START_F403A_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\cherryUSB\class\cdc;..\..\cherryUSB\class\msc;..\..\cherryUSB\common;..\..\cherryUSB\core;..\..\cherryUSB\port\dwc2;..\..\cherryUSB\demo;..\..\cherryUSB;..\..\bsp\dwt;..\..\bsp\sdio
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ../src/: main.c at32f403a_407_wk_config.c at32f403a_407_int.c wk_system.c wk_acc.c wk_debug.c wk_sdio.c wk_usart.c wk_usbfs.c rtc.c
  group firmware
    ../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_tmr.c at32f403a_407_rtc.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_usart.c at32f403a_407_pwc.c at32f403a_407_adc.c at32f403a_407_spi.c at32f403a_407_dma.c at32f403a_407_flash.c at32f403a_407_crc.c at32f403a_407_wwdt.c at32f403a_407_wdt.c at32f403a_407_exint.c at32f403a_407_misc.c at32f403a_407_usb.c at32f403a_407_acc.c at32f403a_407_can.c at32f403a_407_dac.c at32f403a_407_xmc.c at32f403a_407_emac.c at32f403a_407_sdio.c at32f403a_407_debug.c at32f403a_407_bpr.c
  group cmsis
    ./: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group bsp
    ../../bsp/sdio/: at32_sdio.c at32_sdio.h
    ../../bsp/dwt/: bsp_dwt.c bsp_dwt.h
  group cherryUSB_core
    ../../cherryUSB/core/: usbd_core.c usbd_core.h
    ../../cherryUSB/: usb_config.h
  group cherryUSB_class
    ../../cherryUSB/class/msc/: usb_msc.h usb_scsi.h usbd_msc.c usbd_msc.h
    ../../cherryUSB/class/cdc/: usb_cdc.h usbd_cdc.h usbd_cdc_acm.c usbd_cdc_acm.h
  group cherryUSB_port
    ../../cherryUSB/port/dwc2/: usb_dc_dwc2.c usb_glue_at.c
    ../../cherryUSB/port/fsdev/: usb_dc_fsdev.c usb_fsdev_reg.h
  group cherryUSB_demo
    ../../cherryUSB/demo/: cdc_acm_msc_template.c msc_ram_template.c
